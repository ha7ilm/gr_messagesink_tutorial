<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>rtl=0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>100e6</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>1.0</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>dont_block</key><value>False</value></param>
<param><key>vlen</key><value>4096</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value></value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_message_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>msg</source_key><sink_key>0</sink_key></connection>
</flow_graph>
